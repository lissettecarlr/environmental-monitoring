# Keil uVision project demo.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\lib\math;..\..\..\lib\onchip\ADC;..\..\..\lib\onchip\capture;..\..\..\lib\onchip\delay;..\..\..\lib\onchip\flash;..\..\..\lib\onchip\GPIO;..\..\..\lib\onchip\I2C;..\..\..\lib\onchip\interrupt;..\..\..\lib\onchip\PWM;..\..\..\lib\onchip\taskManager;..\..\..\lib\onchip\timer;..\..\..\lib\onchip\USART;..\..\..\lib\offchip\LED;.\app;..\..\..\lib\offchip\HCHO;..\..\..\lib\offchip\MHZ14;..\..\..\lib\offchip\ZPH01;..\..\..\lib\offchip\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib/onchip
    ../../../lib/onchip/ADC/: ADC.cpp
    ../../../lib/onchip/capture/: InputCapture_EXIT.cpp InputCapture_TIM.cpp
    ../../../lib/onchip/delay/: Delay.cpp
    ../../../lib/onchip/flash/: Flash.cpp
    ../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../lib/onchip/I2C/: I2C.cpp
    ../../../lib/onchip/interrupt/: Interrupt.cpp
    ../../../lib/onchip/PWM/: PWM.cpp
    ../../../lib/onchip/taskManager/: TaskManager.cpp
    ../../../lib/onchip/timer/: Timer.cpp
    ../../../lib/onchip/USART/: USART.cpp
  group lib/offchip
    ../../../lib/offchip/LED/: LED.cpp
    ../../../lib/offchip/HCHO/: HCHO.cpp
    ../../../lib/offchip/MHZ14/: MHZ14.cpp
    ../../../lib/offchip/ZPH01/: ZPH01.cpp
    ../../../lib/offchip/ESP8266/: ESP8266.cpp
  group app
    ./app/: Main.cpp Configuration.h UserInterrupt.cpp Communication.cpp
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
